# Keil uVision project SPL_13_ADC_ISR.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F302R8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SPL_13_ADC_ISR
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F302x8
  c include: ..\include;..\STM32F30x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ../source/: main.c cadc_stm32f3.c ctimers_stm32f3.c
    ../STM32F30x_StdPeriph_Driver/bin/: SPL_STM32F302x8.lib
software components: CMSIS:CORE 4.1.0, Device:Startup 1.2.0
